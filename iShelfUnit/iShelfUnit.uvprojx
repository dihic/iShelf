# Keil uVision project iShelfUnit.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC11C24FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.3.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: iShelfUnit +hex
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: canonchip.c iso15693.c main.cpp trf796x.c vcnl40x0.cpp delay.c
  group Driver
    ./: gpio.c ssp.c I2CMaster.cpp I2C.c timer32.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
